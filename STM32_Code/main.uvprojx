# Keil uVision project main.uvprojx, settings and files
target Motor_Control (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Motor_Control;.\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers
    ./: Timer.h GPIO.h RCC.h USART.h Timer.c RCC.c USART.c
  group Tasks
    ./: motor_task.h motor_task.c encoder_task.h encoder_task.c uart_task.h uart_task.c
  group Main
    ./: main.c main.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
